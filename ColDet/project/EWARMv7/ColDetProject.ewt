<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\CMSIS\Device\ST\STM32F2xx\Source\Templates\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\CMSIS\Device\ST\STM32F2xx\Source\Templates\iar\startup_stm32f2xx.s</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\crc8.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\func.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\rs485.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\stm32f2xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\TB6560AHQ.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\tcs3200.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\temp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\TLC59711.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\usart.c</name>
    </file>
  </group>
</project>


