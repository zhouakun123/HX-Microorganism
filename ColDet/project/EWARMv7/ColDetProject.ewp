# IAR project ColDetProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VC ST STM32F207VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: ..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\..\STM32_Libraries\STM32F2xx_Std_Lib_V1.1.0\F2xx_12Mhz\STM32F2xx_StdPeriph_Driver\inc; ..\..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ColDetProject.hex
  ILINK.IlinkOutputFile: ColDetProject.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../../STM32_Libraries/STM32F2xx_Std_Lib_V1.1.0/F2xx_12Mhz/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Startup
    ../../../../../STM32_Libraries/STM32F2xx_Std_Lib_V1.1.0/F2xx_12Mhz/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group StdPeriph_Driver
    ../../../../../STM32_Libraries/STM32F2xx_Std_Lib_V1.1.0/F2xx_12Mhz/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group User
    ../../src/: adc.c crc8.c delay.c func.c iwdg.c main.c rs485.c stm32f2xx_it.c TB6560AHQ.c tcs3200.c temp.c timer.c TLC59711.c usart.c
